# IAR project xmc1404_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: XMC1404-F064x0200 Infineon XMC1404-F064x0200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: xmc1404_test.bin
  ILINK.IlinkOutputFile: xmc1404_test.out
  ILINK.IlinkIcfFile: C:\programs\MCU\infineon\XMC1000\xmc_1404_bmw_autosar\config\XMC1404xxxxx200.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: atostar_crc.c bignum.c can.c gpio.c main.c scu.c startup_XMC1400.s string.c system_XMC1400.c uart.c
  group kern
    kern/: kern.c kern_arch.s kern_event.c kern_mem.c kern_mutex.c kern_queue.c kern_sem.c kern_tasks.c kern_utils.c
